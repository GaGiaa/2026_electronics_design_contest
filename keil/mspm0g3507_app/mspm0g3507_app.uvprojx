# Keil uVision project mspm0g3507_app.uvprojx, settings and files
target mspm0g3507_app (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(80000000) ELITTLE
  output: mspm0g3507_app +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "$P..\..\tools\generate-keil-mspm0g3507-sysconfig.ps1" -ProjectRoot "$P..\.."
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\mspm0g3507_app;..\..\mspm0g3507_app\motor_pid;.\Generated;D:\Software\ti\ccs2020\mspm0_sdk_2_11_00_07\source;D:\Software\ti\ccs2020\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include;D:\Software\ti\ccs2020\mspm0_sdk_2_11_00_07\kernel\freertos\Source\include;.\freertos_port\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../mspm0g3507_app/: main.c board_encoder.c board_buzzer.c board_buttons.c board_grayscale.c board_bmi160.c board_motor.c motor_control.c board_uart.c board_ws2812.c FreeRTOSConfig.h mspm0g3507_app.syscfg
    ../../mspm0g3507_app/motor_pid/: pid.c
    ./: startup_mspm0g350x_uvision.s
    Generated/: ti_msp_dl_config.h ti_msp_dl_config.c
  group FreeRTOS
    D:/Software/ti/ccs2020/mspm0_sdk_2_11_00_07/kernel/freertos/Source/: list.c queue.c tasks.c
    freertos_port/ARM_CM0/: port.c portasm.c
  group Driverlib
    D:/Software/ti/ccs2020/mspm0_sdk_2_11_00_07/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
